# Keil uVision project GPIO.uvprojx, settings and files
target stm32f4 (6190000::V6.19::ARMCLANG)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./: main.cpp
  group drivers
    ./: my_stm32f4_gpio_driver.h stm32f4_systick_driver.h
  group libs
    ./: my_stm32f4_systick_lib.h my_stm32f4_systick_lib.cpp my_stm32f4_gpio_lib.cpp my_stm32f4_gpio_lib.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
